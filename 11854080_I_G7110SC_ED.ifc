Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, FMHandOverView]
File name: Project Number
Time: 2021-10-07T14:36:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20190508_0315(x64) - Exporter 17.0.1169.0 - Default UI
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Thu Oct 07 14:36:10 2021 * Host: DEGTW9512 * Database: C:\Users\deschvi\AppData\Local\Temp\{3A6C6622-E073-424F-B2CA-ACDC654526E5}\ifc * Database version: 5507 * Database creation date: Thu Oct 07 14:36:09 2021 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Thu Oct 07 14:36:09 2021 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Thu Oct 07 14:36:09 2021 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm

# IfcBuildingElementProxy: 21711018_I_11854080_G7110SC_ED, 11854080_I_G7110SC_ED:21711018_I_11854080_G7110SC_ED:209578
In: Level 1
Type - Material: z_Miele_Design_Glass Black, z_Miele_Design_CLST, z_Miele_Connection_Electric, z_Miele_Connection_Water_OUT, z_Miele_Connection_Water_IN, Polypropylene, z_Miele_Design_Steel_Chrom
Pset_BuildingElementProxyCommon - Reference: 21711018_I_11854080_G7110SC_ED
Pset_ManufacturerTypeInformation - Manufacturer: Miele
